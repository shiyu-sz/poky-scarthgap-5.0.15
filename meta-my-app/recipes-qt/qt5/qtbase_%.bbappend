
# 这里的配置对应你之前在 local.conf 里的修改
PACKAGECONFIG:append = " linuxfb gbm kms eglfs libinput udev"